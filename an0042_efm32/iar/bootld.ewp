# IAR project bootld.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32HG322F64 SiliconLaboratories EFM32HG322F64
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: EFM32HG322F64
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\SiliconLabs\EFM32HG\Include; ..\..\..\emlib\inc; ..\..\..\usb\inc; ..\..\..\kits\common\drivers; ..\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\CMSIS\Include; ..\..\..\Device\SiliconLabs\EFM32GG\Include; ..\..\..\emlib\inc; ..\..\..\usb\inc; ..\..\..\kits\common\drivers; ..\src
  OBJCOPY.OOCOutputFile: bootld.bin
  ILINK.IlinkOutputFile: bootld.out
  ILINK.IlinkIcfFile: C:\SiliconLabs\SimplicityStudio\v3\developer\sdks\efm32\v2\an\an0042_efm32_usb_uart_bootloader\src\EFM32HG-romram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32HG322F64
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../SiliconLabs/SimplicityStudio/v3/developer/sdks/efm32/v2/an/an0042_efm32_usb_uart_bootloader/src/: startup_efm32hg.s
    ../../../../SiliconLabs/SimplicityStudio/v3/developer/sdks/efm32/v2/Device/SiliconLabs/EFM32HG/Source/: system_efm32hg.c
  group drivers
    ../../../kits/common/drivers/: retargetio.c
  group emlib
    ../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_int.c em_system.c em_timer.c em_usart.c
  group Source
    ../src/: autobaud.c boot.c bootldio.c cdc.c crc.c flash.c main.c retargetdebug.c xmodem.c
  group usb
    ../../../usb/src/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbdint.c em_usbhal.c em_usbtimer.c
