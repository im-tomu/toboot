<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\bootld.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\bootldld.ewp</path>
  </project>

  <batchBuild/>
</workspace>
