# IAR project bootldld.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG990F1024 SiliconLaboratories EFM32GG990F1024
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EFM32GG990F1024
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\SiliconLabs\EFM32GG\Include; ..\..\..\emlib\inc; ..\..\..\usb\inc; ..\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bootldld.bin
  ILINK.IlinkOutputFile: bootldld.out
  ILINK.IlinkIcfFile: ..\src\EFM32-rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG990F1024
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../Device/SiliconLabs/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../../../Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group Source
    ../src/: boot.c loader.c
